PACKAGECONFIG = "drm osmesa freetype2 gbm egl gles1 gles2 glew glu glx"
#PACKAGECONFIG = "egl"
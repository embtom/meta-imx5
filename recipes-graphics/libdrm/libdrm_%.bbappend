PACKAGECONFIG = "libkms udev freedreno install-test-programs"